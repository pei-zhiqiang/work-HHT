# Keil uVision project codec.uvprojx, settings and files
target codec (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743VIT6_Aids_CDC +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_USB_FS,NO_BL_NO_DEBUG,USE_USB_CDC_CONFIG,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=870
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP/Main;../APP/Component;../APP/Protocol;../Drivers/USER_Driver;../Utilities;../Algorithm/AGC;../Algorithm/VC;../Algorithm/WDRC;../Middlewares/cm_backtrace/port;../Middlewares/cm_backtrace/src;../Middlewares/FAL/inc;../Middlewares/FAL/port;../Middlewares/SFUD/inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USB_DEVICE_Audio/App;../USB_DEVICE_Audio/Target;../Middlewares/ST_USB_AUDIO_Liarbry/Class/AUDIO/Inc;../Middlewares/ST_USB_AUDIO_Liarbry/Core/Inc;../Middlewares/GUI;../Middlewares/GUI/lvgl;../Middlewares/GUI/lvgl_app;../Middlewares/GUI/lvgl_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VIT6_Aid_DMIC_4MIC.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c bdma.c dma.c i2c.c rtc.c sai.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group APP/Component
    ../APP/Component/: Flash_Port.c LED_Port.c Timer_Port.c UART_Port.c I2C_Port.c Update_Port.c Parameter_Port.c Voltameter_Port.c SAI_Port.c Gyroscope_Port.c PressKey_Port.c Power_Management_Port.c DAC_Port.c Tips_Audio_Port.c USB_Audio_Port.c ADC_Port.c Audio_Debug.c TP_Port.c LCD_Port.c BT8829_Signal_Port.c RTC_Port.c
  group APP/Main
    ../APP/Main/: User_Main.c
  group APP/Protocol
    ../APP/Protocol/: Update_Protocol.c File_Transfer_Protocol.c Main_Protocol.c
  group USER_Driver
    ../Drivers/USER_Driver/: MAX17048_Driver.c MPU6050_Driver.c WM8978_Driver.c LCD_Driver.c TP_Driver.c
  group Algorithm
    ./: Aids_Algorithm_lib.lib
  group Utilities
    ../Utilities/: CircularQueue.c utilities.c utilities_crc.c Utilities_Multi_Button.c Utilities_Multi_Timer.c
  group Middleware/CM_backtrace/port
    ../Middlewares/cm_backtrace/port/: cm_backtrace_port.c cmb_cfg.h
  group Middleware/CM_backtrace/src
    ../Middlewares/cm_backtrace/src/: cm_backtrace.c
  group Middleware/FAL/port
    ../Middlewares/FAL/port/: fal_flash_stm32h7_port.c fal_cfg.h fal_flash_sfud_port.c
  group Middleware/FAL/src
    ../Middlewares/FAL/src/: fal.c fal_flash.c fal_partition.c
  group Middleware/SFUD/port
    ../Middlewares/SFUD/port/: sfud_port.c
  group Middleware/SFUD/src
    ../Middlewares/SFUD/src/: sfud.c sfud_sfdp.c
  group Middlewares/GUI/port
    ../Middlewares/GUI/lvgl_port/: lv_port.c lv_port_disp.c lv_port_indev.c
  group Middlewares/GUI/app
    ../Middlewares/GUI/lvgl_app/: lv_app.c logo.c main_set_90.c main_bf_160.c main_vol_left_40.c main_bf_170.c main_vol_right_40.c bf_100.c ns_100.c set_100.c vol_100.c hht_font_30.c hht_font_72.c ble_90.c brightness_90.c reset_90.c mode_90.c hht_font_50.c lv_app_test.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group USB_DEVICE_Audio
    ../USB_DEVICE_Audio/App/: AUDIO_usb_device.c AUDIO_usbd_desc.c usbd_audio_if.c
    ../USB_DEVICE_Audio/Target/: AUDIO_usbd_conf.c
  group Middlewares/ST_USB_AUDIO_Liarbry
    ../Middlewares/ST_USB_AUDIO_Liarbry/Class/AUDIO/Src/: usbd_audio.c
  group Middlewares/ST_USB_AUDIO_Liarbry/Core
    ../Middlewares/ST_USB_AUDIO_Liarbry/Core/Src/: AUDIO_usbd_core.c AUDIO_usbd_ctlreq.c AUDIO_usbd_ioreq.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/GUI/src
    ../Middlewares/GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Middlewares/GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../Middlewares/GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Middlewares/GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Middlewares/GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
target codec_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: STM32H743VIT6_Aids_APP +hex
  AfterMake: fromelf --bin !L --output STM32H743VIT6_Aids_APP_v4.x.bin
  c flags: as above
  c define: USE_HAL_DRIVER,STM32H743xx,USE_USB_FS,USE_USB_CDC_CONFIG,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=870
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\APP\Main;../APP/Component;../APP/Protocol;..\Drivers\USER_Driver;../Utilities;../Algorithm/AGC;../Algorithm/VC;../Algorithm/WDRC;..\Middlewares\cm_backtrace\port;..\Middlewares\cm_backtrace\src;..\Middlewares\FAL\inc;..\Middlewares\FAL\port;..\Middlewares\SFUD\inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\USB_DEVICE_Audio\App;..\USB_DEVICE_Audio\Target;..\Middlewares\ST_USB_AUDIO_Liarbry\Class\AUDIO\Inc;..\Middlewares\ST_USB_AUDIO_Liarbry\Core\Inc;..\Middlewares\GUI;..\Middlewares\GUI\lvgl;..\Middlewares\GUI\lvgl_app;..\Middlewares\GUI\lvgl_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VIT6_Aid_DMIC_4MIC_App.sct
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
